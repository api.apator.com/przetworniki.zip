Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: MWN130-50-NC.IFC
Time: 2025-08-01T08:31:03
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: 0000-002232-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 0000-002761-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 0000-002899-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1170-000002-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2440-000002-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2440-010102-3-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2440-010102-3-solid2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2440-010102-3-solid3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2440-010102-3-solid4
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2440-010102-3-solid5
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7010-000005-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7610-000001-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie6
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Drut do plomb MWN NKNC-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Drut do plomb miedziany w oplocie 0,3x0,6x300 (MWN50-NK_1)-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Nitoko³ek 2,89x6,35 - A2-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Nitoko³ek 2,89x6,35 - A2-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Plomba BN-89-8511-15-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Plomba BN-89-8511-15-3-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba PN-85_M-82215 M5x12-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba PN-85_M-82215 M5x12-3-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba PN-85_M-82215 M5x16-1-solid1
In: Default Storey
PredefinedType: ELEMENT
