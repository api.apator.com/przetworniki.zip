Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: MWN130-80-NC.IFC
Time: 2025-08-01T09:46:48
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: 7300-000007-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7380-000000-1/0000-002746-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7380-000000-1/Nitoko³ek 2,89x6,35 - A2-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid10
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid11
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid12
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid13
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid14
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid15
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid16
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid17
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid18
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid5
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid6
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid7
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid8
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid9
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie7
In: Default Storey
PredefinedType: ELEMENT
