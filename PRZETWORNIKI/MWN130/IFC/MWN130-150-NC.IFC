Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: MWN130-300-NC.IFC
Time: 2025-08-01T10:52:02
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: 1170-000002-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2440-000002-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7050-000003-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7370-010000-1/Œruba z uchem M10-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7370-010000-1/Œruba z uchem M10-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7510-000002-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7610-000004-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8027-010000-1/8027-010001-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8027-010000-1/8027-010100-1/2440-010102-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8027-010000-1/8027-010100-1/2440-010102-1-solid2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8027-010000-1/8027-010100-1/2440-010102-1-solid3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8027-010000-1/8027-010100-1/2440-010102-1-solid4
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8027-010000-1/8027-010100-1/2440-010102-1-solid5
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8027-010000-1/8027-010100-1/8027-010200-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie10[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie4
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie5
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie6[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie7
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Plomba fi10-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Plomba fi10-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka 17-0H18N9-11-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka 17-0H18N9-13-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka 17-0H18N9-15-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka 17-0H18N9-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka 17-0H18N9-4-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka 17-0H18N9-6-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka 17-0H18N9-8-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: drut 7375 NC-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba PN-85_M-82215 M4x10-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba PN-85_M-82215 M5x12-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba PN-85_M-82215 M5x12-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba PN-85_M-82215 M5x16-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba PN-87_M-82302 M16x45-10-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba PN-87_M-82302 M16x45-11-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba PN-87_M-82302 M16x45-12-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba PN-87_M-82302 M16x45-15-solid1
In: Default Storey
PredefinedType: ELEMENT
