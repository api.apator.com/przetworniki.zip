Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: MWN130-250-NC.IFC
Time: 2025-08-01T11:58:28
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: 5003-110012-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7070-000001-1-solid2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7360-010000-1/7360-010100-1/7050-010102-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7360-010000-1/Œruba z uchem M10-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7360-010000-1/Œruba z uchem M10-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid10
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid11
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid12
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid13
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid14
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid15
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid16
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid17
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid18
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid19
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid20
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid4
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid7
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid8
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7605-000000-1-solid9
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka PN-82005-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka PN-82005-10-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka PN-82005-12-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka PN-82005-14-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka PN-82005-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka PN-82005-4-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka PN-82005-6-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka PN-82005-8-solid1
In: Default Storey
PredefinedType: ELEMENT
