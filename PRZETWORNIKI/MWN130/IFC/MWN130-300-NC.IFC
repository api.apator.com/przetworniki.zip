Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: MWN130-300-NC.IFC
Time: 2025-08-01T11:13:40
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: 0000-002232-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 0000-002746-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 0000-003317-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1170-000002-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2440-000002-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2440-010102-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2440-010102-1-solid2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2440-010102-1-solid3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2440-010102-1-solid4
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2440-010102-1-solid5
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7010-000005-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7360-010000-1/Œruba z uchem M10-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7360-010000-1/Œruba z uchem M10-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7510-000002-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7610-000001-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7610-000004-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie10
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Drut do plomb miedziany w oplocie 0,3x0,6x300 (MWN50-NK_1)-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Nitoko³ek 2,89x6,35 - A2-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Nitoko³ek 2,89x6,35 - A2-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Plomba BN-89-8511-15-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka 17-0H18N9-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka 17-0H18N9-10-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka 17-0H18N9-12-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka 17-0H18N9-14-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka 17-0H18N9-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka 17-0H18N9-4-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka 17-0H18N9-8-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: produkt gotowy-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba M4x8-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba PN-85_M-82215 M5x10-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba PN-85_M-82215 M5x10-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba PN-87_M-82302 M5x16-1-solid1
In: Default Storey
PredefinedType: ELEMENT
