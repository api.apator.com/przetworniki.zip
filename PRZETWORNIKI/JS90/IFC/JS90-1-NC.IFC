Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: JS90-1-NC.IFC
Time: 2025-08-01T07:01:45
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: 1170-000002-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2440-000002-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9051-000001-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9550-000000-Drut do plomb 0,5-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie5
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Plomba fi10-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba M-82302-1-solid1
In: Default Storey
PredefinedType: ELEMENT
