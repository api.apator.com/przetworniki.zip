Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: JS90-1,5-G1-NC.IFC
Time: 2025-08-01T07:34:10
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: 1170-000002-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2440-000002-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9051-000001-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9051-020000-1/9051-020000-zywica-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9051-020000-1/9051-020001-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9051-020000-1/9051-020100-2/9051-020101-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9051-020000-1/9051-020100-2/9051-020102-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9051-020000-1/9051-020100-2/Kondensator SMD 1206 10pF-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9051-020000-1/9051-020100-2/Kontaktron MSDR-4 model 1111 27-38 AW-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9051-020000-1/9051-020100-2/Rezystor SMD 1206 G 10?-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9550-000000-Drut do plomb 0,5-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie5
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Drut do plomb miedziany w oplocie 0,5x0,3x100-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Plomba fi10-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Plomba fi10-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba PN-87_M-82302 M4x10-1-solid1
In: Default Storey
PredefinedType: ELEMENT
